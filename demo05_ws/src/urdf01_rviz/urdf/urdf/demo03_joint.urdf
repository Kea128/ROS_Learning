Commit message: ver_0716_xacro

File: demo05_ws/src/urdf01_rviz/urdf/urdf/demo03_joint.urdf (robot description, URDF)
Before this commit: robot mycar, 2 links, 1 joints
Joints:
- joint camera2base: origin xyz=0.12 0 0.05 rpy=0 0 0 -> xyz=0.12 0 0.075 rpy=0 0 0
